# Keil uVision project USBD_Printer_and_HID_Transfer.uvprojx, settings and files
target USBD_Printer_and_HID_Transfer (6160000::V6.16::ARMCLANG)
  device: M071SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USBD_Printer_and_HID_Transfer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M071R_M071S\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M071R_M071S.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071R_M071S/Source/: system_M071R_M071S.c
    ../../../../Library/Device/Nuvoton/M071R_M071S/Source/ARM/: startup_M071R_M071S.s
  group User
    ../: descriptors.c micro_printer_and_hid_transfer.c main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c sys.c clk.c

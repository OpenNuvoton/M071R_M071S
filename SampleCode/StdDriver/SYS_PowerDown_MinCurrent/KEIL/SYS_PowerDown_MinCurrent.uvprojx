# Keil uVision project SYS_PowerDown_MinCurrent.uvprojx, settings and files
target SYS_PowerDown_MinCurrent (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M071SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SYS_PowerDown_MinCurrent
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M071R_M071S\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M071R_M071S.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071R_M071S/Source/: system_M071R_M071S.c
    ../../../../Library/Device/Nuvoton/M071R_M071S/Source/ARM/: startup_M071R_M071S.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c gpio.c clk.c sys.c uart.c

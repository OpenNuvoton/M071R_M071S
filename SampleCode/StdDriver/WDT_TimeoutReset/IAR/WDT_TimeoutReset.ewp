# IAR project WDT_TimeoutReset.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M071R_S series Nuvoton M071R/M071S series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M071R_M071S\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WDT_TimeoutReset.bin
  ILINK.IlinkOutputFile: WDT_TimeoutReset.out
  ILINK.IlinkIcfFile: WDT_TimeoutReset.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071R_M071S/Source/IAR/: startup_M071R_M071S.s
    ../../../../Library/Device/Nuvoton/M071R_M071S/Source/: system_M071R_M071S.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c wdt.c
  group User
    ../: main.c

# IAR project USBD_HID_Transfer_and_Keyboard.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M071R_S series Nuvoton M071R/M071S series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M071R_M071S\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_HID_Transfer_and_Keyboard.bin
  ILINK.IlinkOutputFile: USBD_HID_Transfer_and_Keyboard.out
  ILINK.IlinkIcfFile: USBD_HID_Transfer_and_Keyboard.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071R_M071S/Source/IAR/: startup_M071R_M071S.s
    ../../../../Library/Device/Nuvoton/M071R_M071S/Source/: system_M071R_M071S.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c usbd.c
  group User
    ../: descriptors.c HID_Transfer_and_Keyboard.c main.c

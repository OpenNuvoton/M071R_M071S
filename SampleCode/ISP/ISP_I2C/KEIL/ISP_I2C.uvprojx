# Keil uVision project ISP_I2C.uvprojx, settings and files
target ISP_I2C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M071SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.9
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: ISP_I2C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M071R_M071S\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M071R_M071S.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071R_M071S/Source/: system_M071R_M071S.c
    ../../../../Library/Device/Nuvoton/M071R_M071S/Source/ARM/: startup_M071R_M071S.s
  group User
    ../: fmc_user.c isp_user.c main.c targetdev.c i2c_transfer.c

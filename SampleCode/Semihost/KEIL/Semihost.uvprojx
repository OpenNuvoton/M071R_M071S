# Keil uVision project Semihost.uvprojx, settings and files
target Semihost (6160000::V6.16::ARMCLANG)
  device: M071SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.19
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Semihost
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c define: DEBUG_ENABLE_SEMIHOST=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M071R_M071S\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M071R_M071S.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M071R_M071S/Source/ARM/: startup_M071R_M071S.s
    ../../../Library/Device/Nuvoton/M071R_M071S/Source/: system_M071R_M071S.c
  group User
    ../: main.c README.txt
  group Library
    ../../../Library/StdDriver/src/: retarget.c
